# Keil uVision project ThermalCam.uvprojx, settings and files
target DEBUG (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: GD32F103VE GigaDevice
  pack: GigaDevice.GD32F10x_DFP.2.0.3
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Power +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F10X_HD
  c include: ..\Libraries\FWlib\Include;..\Libraries\CMSIS;..\User;..\emwin\Include;..\emwin;..\emwin\Application
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Startup
    ../Libraries/CMSIS/startup/: startup_gd32f10x_hd.s
  group CMSIS
    ../Libraries/CMSIS/: system_gd32f10x.c
  group FWLB
    ../Libraries/FWlib/Source/: gd32f10x_adc.c gd32f10x_bkp.c gd32f10x_can.c gd32f10x_crc.c gd32f10x_dac.c gd32f10x_dbg.c gd32f10x_dma.c gd32f10x_enet.c gd32f10x_exmc.c gd32f10x_exti.c gd32f10x_fmc.c gd32f10x_fwdgt.c gd32f10x_gpio.c gd32f10x_i2c.c gd32f10x_misc.c gd32f10x_pmu.c gd32f10x_rcu.c gd32f10x_rtc.c gd32f10x_sdio.c gd32f10x_spi.c gd32f10x_timer.c gd32f10x_usart.c gd32f10x_wwdgt.c
  group USER
    ../User/: main.c GPIO.c TIM.c systick.c Temp-adc.c gd32f10x_it.c gd32f103c_lcd_eval.c gd25qxx.c bmp.c
    ../User/MLX90640/functions/: MLX90640.c MLX90640_API.c MLX90640_SWI2C_Driver.c
  group USB
    ../USB/GD32F10x_usbd_driver/Source/: usbd_core.c usbd_int.c usbd_pwr.c usbd_std.c
    ../USB/: bbb_scsi_driver.c flash_access.c msc_core.c
  group FATFS
    ../FATFS/: diskio.c ff.c
target RELEASE (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: GD32F103C8 GigaDevice
  pack: GigaDevice.GD32F10x_DFP.2.0.3
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Power +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F10X_MD,QL_RELEASE
  c include: ..\Libraries\FWlib\Include;..\Libraries\CMSIS;..\User;..\User\MLX90640\headers;..\USB\GD32F10x_usbd_driver\Include;..\USB;..\FATFS
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
software components: CMSIS:CORE 5.1.2
